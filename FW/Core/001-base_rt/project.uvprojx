# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AIR32F103CC Generic
  pack: Keil.AIR32F103_DFP.1.1.9
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  BeforeMake: mksymlink.bat
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=4 wLevel=3
  c define: __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARMLIBC, RT_USING_LIBC, __STDC_LIMIT_MACROS
  c misc: -DHCPPRT_NO_NEW_AND_DELETE_OVERRIDE=1
  c include: ..\3rdparty\rt-thread\master\components\finsh;board\ports;HCppBox\hbox\cpp;..\3rdparty\rt-thread\master\components\libc\cplusplus;board;..\3rdparty\rt-thread\master\components\drivers\include;..\3rdparty\rt-thread\master\components\fal\inc;..\3rdparty\rt-thread\master\components\libc\posix\io\eventfd;..\3rdparty\rt-thread\master\components\drivers\include;..\3rdparty\rt-thread\master\libcpu\arm\cortex-m3;..\3rdparty\rt-thread\master\components\dfs\dfs_v1\filesystems\tmpfs;..\3rdparty\rt-thread\master\components\libc\posix\io\poll;USB\air32_USB-FS-Device_Driver\inc;..\3rdparty\rt-thread\master\components\drivers\include;..\3rdparty\rt-thread\master\components\drivers\spi;..\3rdparty\rt-thread\master\components\libc\cplusplus\os;libraries\rt_drivers;libraries\CMSIS\Include;..\3rdparty\rt-thread\master\components\libc\compilers\common\extension\fcntl\octal;USB\CONFIG;.;..\3rdparty\rt-thread\master\components\libc\posix\ipc;..\3rdparty\rt-thread\master\include;..\3rdparty\rt-thread\master\components\libc\compilers\common\extension;..\3rdparty\rt-thread\master\components\drivers\include;..\3rdparty\rt-thread\master\components\libc\posix\io\epoll;applications;..\3rdparty\rt-thread\master\components\drivers\include;HCppBox\hbox\cpp;..\3rdparty\rt-thread\master\components\drivers\include;HCppBox\hbox;..\3rdparty\rt-thread\master\components\libc\compilers\common\include;..\3rdparty\rt-thread\master\components\dfs\dfs_v1\filesystems\devfs;..\3rdparty\rt-thread\master\components\dfs\dfs_v1\include;libraries\AIR32F10xLib\inc;..\3rdparty\rt-thread\master\components\legacy\dfs;..\3rdparty\rt-thread\master\components\drivers\include;..\3rdparty\rt-thread\master\components\drivers\include;..\3rdparty\rt-thread\master\components\legacy;USB;..\3rdparty\rt-thread\master\components\drivers\include;HCppBox\hrc;libraries;..\3rdparty\rt-thread\master\libcpu\arm\common;..\3rdparty\rt-thread\master\components\drivers\include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: rs485.cpp aht20.c led.c usb-cdc-acm.cpp main.c wdt.c
  group Compiler
    ../3rdparty/rt-thread/master/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../3rdparty/rt-thread/master/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPP
    ../3rdparty/rt-thread/master/components/libc/cplusplus/: cxx_crt.cpp cxx_crt_init.c
    ../3rdparty/rt-thread/master/components/libc/cplusplus/os/: cxx_Mutex.cpp cxx_Semaphore.cpp cxx_Thread.cpp
  group DeviceDrivers
    ../3rdparty/rt-thread/master/components/drivers/core/: device.c
    ../3rdparty/rt-thread/master/components/drivers/hwtimer/: hwtimer.c
    ../3rdparty/rt-thread/master/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    ../3rdparty/rt-thread/master/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../3rdparty/rt-thread/master/components/drivers/misc/: rt_null.c rt_zero.c
    ../3rdparty/rt-thread/master/components/drivers/pin/: pin.c
    ../3rdparty/rt-thread/master/components/drivers/rtc/: rtc.c soft_rtc.c
    ../3rdparty/rt-thread/master/components/drivers/serial/: serial.c
    ../3rdparty/rt-thread/master/components/drivers/spi/: spi_core.c spi_dev.c
    ../3rdparty/rt-thread/master/components/drivers/watchdog/: watchdog.c
  group Drivers
    board/: board.c
    libraries/AIR32F10xLib/src/: air32f10x_adc.c air32f10x_bkp.c air32f10x_can.c air32f10x_crc.c air32f10x_dac.c air32f10x_dbgmcu.c air32f10x_dma.c air32f10x_exti.c air32f10x_flash.c air32f10x_fsmc.c air32f10x_gpio.c air32f10x_i2c.c air32f10x_iwdg.c air32f10x_otp.c air32f10x_pwr.c air32f10x_rcc.c air32f10x_rcc_ex.c air32f10x_rtc.c air32f10x_sdio.c air32f10x_spi.c air32f10x_tim.c air32f10x_trng.c air32f10x_usart.c air32f10x_wwdg.c misc.c system_air32f10x.c
    libraries/Startup/arm/: startup_air32f10x.s
    libraries/rt_drivers/: drv_common.c drv_flash.c drv_gpio.c drv_hwtimer.c drv_soft_i2c.c drv_spi.c drv_usart.c drv_wdt.c
  group Fal
    ../3rdparty/rt-thread/master/components/fal/src/: fal_flash.c fal_partition.c fal_rtt.c fal.c
  group Filesystem
    ../3rdparty/rt-thread/master/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../3rdparty/rt-thread/master/components/dfs/dfs_v1/filesystems/tmpfs/: dfs_tmpfs.c
    ../3rdparty/rt-thread/master/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../3rdparty/rt-thread/master/components/finsh/: msh_parse.c cmd.c msh_file.c msh.c shell.c
  group HBox
    HCppBox/hbox/: h3rdparty_printf.c h3rdparty_cjsonutils.c hdefaults.c h3rdparty.c hbase64.c hsimulator.c h3rdparty_pb_decode.c hunicode.c hcompiler.c heventchain.c h3rdparty_pb_common.c hringbuf.c h3rdparty_pb_encode.c heventslots.c heventloop.c hobject.c h3rdparty_cjson.c hwatchdog.c hstacklesscoroutine.c hmemoryheap.c
    HCppBox/hbox/modbus/: hmodbus_tcp_client.c hmodbus_rtu_slave_tiny.c hmodbus_crc.c hmodbus_rtu.c hmodbus_rtu_master.c hmodbus_data.c hmodbus_io_interface.c hmodbus_tcp.c hmodbus_tcp_gateway_server.c
  group HBox_CPP
    HCppBox/hbox/cpp/: hloop.cpp hcpprt.cpp hchain.cpp hslots.cpp hsoftdog.cpp hfifo.cpp
  group HRC
    build/HCppBox/hrc/build/: RC_fs_1.c
    HCppBox/hrc/: RC.c
  group Kernel
    ../3rdparty/rt-thread/master/src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../3rdparty/rt-thread/master/src/klibc/: kstdio.c kstring.c
  group Legacy
    ../3rdparty/rt-thread/master/components/legacy/ipc/: workqueue_legacy.c
  group libcpu
    ../3rdparty/rt-thread/master/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../3rdparty/rt-thread/master/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group USB
    USB/CONFIG/: usb_desc.c usb_istr.c usb_prop.c usb_endp.c hw_config.c usb_pwr.c
    USB/air32_USB-FS-Device_Driver/src/: usb_core.c usb_mem.c usb_regs.c usb_init.c usb_int.c usb_sil.c
    USB/: interface_cdc_acm.cpp system.c
